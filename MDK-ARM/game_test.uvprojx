# Keil uVision project game_test.uvprojx, settings and files
target usb_can Configuration (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: usb_can Configuration +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c misc: --C99
  c include: ..\Inc;       ..\Drivers\STM32F1xx_HAL_Driver\Inc;       ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;       ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;       ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;       ..\Drivers\CMSIS\Include;       ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;    ..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;    ..\Middlewares\Third_Party\FreeRTOS\Source\include;    ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c usbd_desc.c stm32f1xx_it.c usbd_cdc_if.c main.c usbd_conf.c usb_device.c freertos.c usb_parser.c convert_data.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_ll_usb.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_flash.c stm32f1xx_hal_can.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_i2c.c
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f105xc.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c croutine.c timers.c event_groups.c tasks.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
